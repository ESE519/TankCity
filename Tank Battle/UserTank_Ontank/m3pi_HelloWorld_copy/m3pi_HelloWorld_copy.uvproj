# Keil uVision project m3pi_HelloWorld_copy.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: m3pi_HelloWorld_copy
  AfterMake: fromelf --bin -o E:\@L.bin !L
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,
  c misc: --gnu
  c include: .;  m3pi;  mbed;  mbed/LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/LPC1768/LPC1768.sct
  link misc: mbed/LPC1768/cmsis_nvic.o
                 
                mbed/LPC1768/system_LPC17xx.o
                 
                mbed/LPC1768/core_cm3.o
                 
                mbed/LPC1768/stackheap.o
                 
                mbed/LPC1768/startup_LPC17xx.o
                 
                mbed/LPC1768/capi.ar
                 
                mbed/LPC1768/mbed.ar
  group src
    ./: main.cpp
    m3pi/: m3pi.cpp
